.SUBCKT TOP X Y Z
.ENDS TOP
