.SUBCKT TOP vdd gnd A
.ENDS TOP
